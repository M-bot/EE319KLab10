# Keil uVision project Sound.uvproj, settings and files
target Sound (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Sound
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Sound.c DAC.c SysTickInts.c SoundController.c Timer0.c FiFo.c SoundPlayer.c UART.c ST7735.c LCD.s Print.s
  group Object code
    ./: texas.o
